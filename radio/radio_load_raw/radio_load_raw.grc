options:
  parameters:
    generate_options: qt_gui
    id: radio_load_raw
    output_language: python
    title: radio_load_raw
  states: {}

blocks:
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: directory_name
  id: parameter
  parameters:
    label: directory_name
    type: str
    value: '"/home/blaine/Desktop/SRT-Saves/SRT_RAW_SAVE-2020:07:27:10:59:20"'
  states: {}
- name: gr_digital_rf_digital_rf_channel_source_0
  id: gr_digital_rf_digital_rf_channel_source
  parameters:
    dir: directory_name
    end: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    repeat: 'False'
    start: ''
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '2400000'
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [gr_digital_rf_digital_rf_channel_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
