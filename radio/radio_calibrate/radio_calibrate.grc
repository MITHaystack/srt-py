options:
  parameters:
    generate_options: no_gui
    id: radio_calibrate
    output_language: python
    run_options: run
    title: radio_calibrate
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_bins
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_bins*num_integrations
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: num_integrations
    type: float
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/float(num_integrations)
    type: float
    vlen: num_bins
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: num_bins
    long_form: 'True'
    type: cc
  states: {}
- name: directory_name
  id: parameter
  parameters:
    label: directory_name
    type: str
    value: '"."'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_bins
    forward: 'True'
    nthreads: '3'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_bins)
  states: {}
- name: num_bins
  id: parameter
  parameters:
    label: num_bins
    type: intx
    value: '4096'
  states: {}
- name: num_integrations
  id: parameter
  parameters:
    label: num_integrations
    type: intx
    value: '1000'
  states: {}
- name: save_calibration
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import json

      from gnuradio import gr
      import pmt

      import pathlib


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - Calculate Calibration Values"""

          def __init__(self, directory=".", filename="test.rad", vec_length=4096):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32, vec_length)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.directory = directory
              self.filename = filename
              self.vec_length = vec_length

          def work(self, input_items, output_items):
              """Divide Input by Average, Determine Calibration Power, and Save"""
              averaged_input = np.zeros(len(input_items[0][0]))
              for input_array in input_items[0]:
                  averaged_input += input_array
              averaged_input /= len(input_items[0])
              average_value = np.average(averaged_input)
              averaged_input /= average_value
              file_output = {"cal_pwr": average_value, "cal_values": averaged_input.tolist()}
              with open(pathlib.Path(self.directory, self.filename),"w") as outfile:
                  json.dump(file_output, outfile)
              return len(input_items[0])
    directory: directory_name
    filename: '''calibration.json'''
    vec_length: num_bins
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5558
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', dc_blocker_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', save_calibration, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0, '0']
- [dc_blocker_xx_0, '0', blocks_stream_to_vector_0_2, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [zeromq_sub_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
