options:
  parameters:
    generate_options: no_gui
    id: radio_save_raw
    output_language: python
    run_options: run
    title: radio_save_raw
  states: {}

blocks:
- name: directory_name
  id: parameter
  parameters:
    label: directory_name
    type: str
    value: '"./rf_data"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      import pathlib
      from datetime import datetime, timezone
      import time


      def parse_time(rx_time):
          time_since_epoch = (rx_time[0] + rx_time[1])
          date = datetime.fromtimestamp(time_since_epoch, timezone.utc)
          new_year_day = datetime(year=date.year, month=1, day=1, tzinfo=timezone.utc)
          day_of_year = (date - new_year_day).days + 1
          return date.year, day_of_year, date.hour, date.minute, date.second


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, directory=".", filename="test.rad", vec_length=4096):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32, vec_length)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.directory = directory
              self.filename = filename
              self.vec_length = vec_length

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #file = open(pathlib.Path(self.directory, self.filename),"a+")
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              latest_data_dict = {pmt.to_python(tag.key) : pmt.to_python(tag.value) for tag in tags}
              yr, da, hr, mn, sc = parse_time(latest_data_dict['rx_time'])
              print(yr, da, hr, mn, sc)
              for input_array in input_items[0]:
                  header_line = "DATE %4d:%03d:%02d:%02d:%02d obsn %3d az %4.1f el %3.1f freq_MHz %10.4f Tsys %6.3f Tant %6.3f vlsr %7.2f glat %6.3f glon %6.3f source %s"
                  #header_line %= (yr, da, hr, mn, sc, d1.obsn, d1.aznow, d1.elnow, d1.freq, d1.tsys, ppwr, d1.vlsr, d1.glat, d1.glon, soutrack)
                  #print(header_line)
              #file.close()
              return len(input_items[0])
    directory: directory_name
    filename: '''test.rad'''
    vec_length: num_bins
  states: {}
- name: num_bins
  id: parameter
  parameters:
    label: num_bins
    type: intx
    value: '4096'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '2400000'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5560
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: num_bins
  states: {}

connections:
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
