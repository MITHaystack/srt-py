options:
  parameters:
    generate_options: no_gui
    id: radio_save_raw
    output_language: python
    title: radio_save_raw
  states: {}

blocks:
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: pow(2, 16)
    type: complex
  states: {}
- name: directory_name
  id: parameter
  parameters:
    label: directory_name
    value: '"./rf_data"'
  states: {}
- name: gr_digital_rf_digital_rf_channel_sink_0
  id: gr_digital_rf_digital_rf_channel_sink
  parameters:
    center_freqs: '[]'
    checksum: 'False'
    compression_level: '0'
    debug: 'False'
    dir: directory_name
    file_cadence_ms: '1000'
    ignore_tags: 'False'
    input: fc32
    is_continuous: 'True'
    marching_periods: 'True'
    metadata: '{}'
    min_chunksize: '0'
    sample_rate_denominator: '1'
    sample_rate_numerator: int(samp_rate)
    start: '''now'''
    stop_on_skipped: 'False'
    stop_on_time_tag: 'False'
    subdir_cadence_s: '3600'
    uuid: ''
    vlen: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '2400000'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5558
    pass_tags: 'True'
    timeout: '100'
    type: complex
    vlen: pow(2, 16)
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', gr_digital_rf_digital_rf_channel_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
