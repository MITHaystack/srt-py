options:
  parameters:
    author: John Swoboda
    generate_options: qt_gui
    id: radioonly
    output_language: python
    title: radioonly
  states: {}

blocks:
- name: beam_switch
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cal_pwr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: cal_values
  id: variable
  parameters:
    value: np.repeat(np.nan, num_bins)
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc_samples*np.hamming(4*num_bins)
  states: {}
- name: fft_window
  id: variable
  parameters:
    value: window.rectangular(num_bins)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1419e6
  states: {}
- name: glat
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: glon
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: is_running
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: motor_az
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: motor_el
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: 'np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/num_bins) '
  states: {}
- name: sinc_samples
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: soutrack
  id: variable
  parameters:
    value: '"at_stow"'
  states: {}
- name: tcal
  id: variable
  parameters:
    value: '290'
  states: {}
- name: tsys
  id: variable
  parameters:
    value: '171'
  states: {}
- name: vlsr
  id: variable
  parameters:
    value: np.nan
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_bins
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: num_bins
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: num_bins*3
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: num_bins*2
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: num_bins
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: num_integrations_0
    type: float
    vlen: num_bins
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[3*num_bins:]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*num_bins:3*num_bins]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[num_bins:2*num_bins]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:num_bins]
    type: complex
    vlen: num_bins
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/float(num_integrations_0)
    type: float
    vlen: num_bins
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: num_bins*num_integrations
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: num_bins*num_integrations
    long_form: 'False'
    type: cc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: fft_window
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: num_bins
  id: parameter
  parameters:
    label: num_bins
    type: intx
    value: '256'
  states: {}
- name: num_integrations
  id: parameter
  parameters:
    label: num_integrations
    type: intx
    value: '100000'
  states: {}
- name: num_integrations_0
  id: parameter
  parameters:
    label: num_integrations
    type: intx
    value: '10000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=0"'
    bb_gain0: '0'
    corr0: '1000'
    freq0: freq
    gain0: '49'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    update_time: samp_rate/num_integrations/num_bins
    vlen: num_bins
    x_axis_label: '"Frequency"'
    x_start: '-0.5'
    x_step: 1./num_bins
    x_units: '"GHz"'
    y_axis_label: '"Amplitude"'
    y_units: '"deg C"'
    ymax: '.1'
    ymin: '0.001'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    update_time: samp_rate/num_integrations/num_bins
    vlen: num_bins
    x_axis_label: '"Frequency"'
    x_start: freq-samp_rate/2.
    x_step: samp_rate/num_bins
    x_units: '"GHz"'
    y_axis_label: '"Amplitude"'
    y_units: '"deg C"'
    ymax: '.2'
    ymin: '.001'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    update_time: samp_rate/num_integrations/num_bins
    vlen: num_bins
    x_axis_label: '"Frequency"'
    x_start: freq-samp_rate/2.
    x_step: samp_rate/num_bins
    x_units: '"GHz"'
    y_axis_label: '"Amplitude"'
    y_units: '"deg C"'
    ymax: .1*num_integrations_0
    ymin: '0'
  states: {}
- name: usrp0
  id: uhd_usrp_source
  parameters:
    alias: usrp0
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: '"addr=172.25.14.11"'
    gain0: rf_gain
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_0, '0']
- [blocks_skiphead_0, '0', blocks_delay_0_1, '0']
- [blocks_skiphead_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_skiphead_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [usrp0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
